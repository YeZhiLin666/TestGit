# Keil uVision project OSProject.uvproj, settings and files
target LPC4078_WithoutBoot (ARM-ADS)
  device: LPC4078 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: OSProject +hex
  c flags: Optim=1 wLevel=2
  c include: ..\Entry
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\OSProject_WithoutBoot.sct
  group Entry
    ../Entry/: G_DF.h includes.h main.cpp
  group Task_Dispatcher
    ../../COMMON_OS/Task_Dispatcher/: OS_ServeProcess.cpp
  group Protocols
    ../../COMMON_OS/Protocols/: SF_Hwf.h CAN_Hwf.h Uart_Hwf.h
  group Data_Manipulation
    ../../COMMON_OS/Data_Manipulation/: Datatypes.cpp Time_Consum.h CircularQueue_Lin.cpp CircularQueue.h Lib_Mem.cpp Time_Count.cpp Time_Count.h
  group MCU_Core
    ./: startup_LPC407x_8x_177x_8x.s
    ../../COMMON_OS/LPC4078CORE/: system_LPC407x_8x_177x_8x.c CAN.cpp EXTINT.cpp GPIO.cpp IRQ.cpp RTC.cpp SDRAM.cpp SSPI.cpp TIMERS.cpp WDT.cpp PWM.cpp I2CNew.cpp UART.cpp
  group Ext_Devices
    ../../COMMON_OS/Ext_Devices/: LEDFunc.cpp ADC24bit_CS5560.cpp ADC24bit_ADS1259.cpp ADC16bit_AD7606.cpp ADC16bit_AD7656.cpp ADC32bit_LTC2449.cpp ADC32bit_LTC2498.cpp ADC24bit_AD7175.cpp FM25L256.cpp M0Redundant.cpp ControlPin.cpp CPLD.cpp LM75B.cpp PCA9501.cpp TMP75C.cpp DAC16bit_AD5754.cpp DAC16bit_AD5360.cpp EEPROM_24LC128.cpp DAC16bit_AD5764.cpp
  group TCP-NET
    ../../COMMON_OS/TCP-NET/: Net_Config.c Net_lib.c TcpTxRx.cpp TCP_CM3.lib EMAC_LPC177x_8x.cpp
  group EthernetParse
    ../../COMMON_APP/EthernetParse/: EthernetParse.cpp EventsBuffering.cpp MultiMcuCommunication.cpp MultiMcuCommunication.h DebugReadMemory.cpp DebugReadMemory.h
  group CAN_Bus
    ../../COMMON_APP/CANBus/: CANBusParse.cpp CANBusParse.h CANMsgBuffering.cpp CANMsgBuffering.h
  group SMBus
    ../../COMMON_APP/SMBus/: SMBus.cpp
  group UartParse
    ../../COMMON_APP/UartParse/: UartParse.cpp UartParse.h
  group IV_Tasks
    ../IV_Tasks/: BSP.cpp BSP.h CConfig.cpp CConfig.h CheckLimit_4.cpp CheckLimit_4.h CheckLimit_8.cpp CheckLimit_8.h DataManage.cpp DataManage.h IR.cpp IR.h IVSDL.cpp IVSDL.h Metavariable.cpp Metavariable.h OS_LogicProcess.cpp OS_LogicProcess.h PID.cpp PID.h Protocol.h SafeCheck.cpp SafeCheck.h SampleProcess.cpp SampleProcess.h ScheduleDataDefine.h ScheduleManage.cpp ScheduleManage.h StepManage.cpp StepManage.h ThirdParty.cpp ThirdParty.h SimuBuffer.cpp ScheduleStatusReport.cpp ScheduleStatusReport.h Check_V_Limit.cpp Check_V_Limit.h CheckLimit_Non_V.cpp CheckLimit_Non_V.h Pulse.cpp Pulse.h Pulse_LogLimit.h Pulse_LogLimt.cpp Pulse_MV.cpp Pulse_MV.h PULSE_Safety.cpp PULSE_Safety.h SampleProcess_Pulse.cpp SampleProcess_Pulse.h TEC_Ctrl.cpp TEC_Ctrl.h FanAdj.cpp EXCheck.cpp BurstModeSampling.cpp PowerAdj.cpp IndependentVoltageCtrl.cpp
    ../../COMMON_APP/CANBus/: CanbusWatchdog.cpp
  group PWM
    ../HWD/PWM/: PWM_ADC5DAC.cpp PWM_ADC5DAC.h PWM_Base.cpp PWM_Base.h PWM_SampleManage.cpp PWM_SampleManage.h
  group LBT20083
    ../HWD/LBT20083/: LBT20083_ADC5DAC.cpp LBT20083_ADC5DAC.h LBT20083_Base.cpp LBT20083_Base.h LBT20083_SampleManage.cpp LBT20083_SampleManage.h
  group LBT21XXXBase
    ../HWD/LBT21XXXBase/: LBT21XXX_ADC5DAC.cpp LBT21XXX_ADC5DAC.h LBT21XXX_Base.cpp LBT21XXX_Base.h LBT21XXX_SampleManage.cpp LBT21XXX_SampleManage.h
  group LBT20084
    ../HWD/LBT20084/: LBT20084_Base.cpp LBT20084_Base.h
  group LBT20162
    ../HWD/LBT20162/: LBT20162_Base.cpp LBT20162_Base.h
  group LBT21014
    ../HWD/LBT21014/: LBT21014_Base.cpp LBT21014_Base.h
  group LBT21024
    ../HWD/LBT21024/: LBT21024_Base.cpp LBT21024_Base.h
  group HS21044
    ../HWD/HS21044/: HS21044_ADC5DAC.cpp HS21044_ADC5DAC.h HS21044_Base.cpp HS21044_Base.h HS21044_SampleManage.cpp HS21044_SampleManage.h
  group MSTAT21044
    ../HWD/MSTAT21044/: MSTAT21044_Base.cpp MSTAT21044_Base.h
  group LBT21084
    ../HWD/LBT21084/: LBT21084_Base.cpp LBT21084_Base.h
  group LBT21162
    ../HWD/LBT21162/: LBT21162_Base.cpp LBT21162_Base.h
  group LBT22013
    ../HWD/LBT22013/: LBT22013_ADC5DAC.cpp LBT22013_ADC5DAC.h LBT22013_Base.cpp LBT22013_Base.h LBT22013_SampleManage.cpp LBT22013_SampleManage.h
  group LBT22XXXBase
    ../HWD/LBT22XXXBase/: LBT22XXX_ADC5DAC.cpp LBT22XXX_ADC5DAC.h LBT22XXX_Base.cpp LBT22XXX_Base.h LBT22XXX_SampleManage.cpp LBT22XXX_SampleManage.h
  group LBT22023
    ../HWD/LBT22023/: LBT22023_Base.cpp LBT22023_Base.h
  group LBT22043
    ../HWD/LBT22043/: LBT22043_Base.cpp LBT22043_Base.h
  group HPT200
    ../HWD/HPT200/: HPT200_ADC5DAC.cpp HPT200_ADC5DAC.h HPT200_Base.cpp HPT200_Base.h HPT200_SampleManage.cpp HPT200_SampleManage.h
  group HPM4
    ../HWD/HPM4/: HPM4_ADC5DAC.h HPM4_ADC5DAC.cpp HPM4_Base.h HPM4_Base.cpp HPM4_SampleManage.h HPM4_SampleManage.cpp
  group BUILT-IN_16V
    ../HWD/BUILT-IN_16V/: BUILT-IN_16V_409386_Base.cpp BUILT-IN_16V_409386_Base.h
  group BUILT-IN_16T
    ../HWD/BUILT-IN_16T/: BUILT-IN_16T_409920_Base.cpp BUILT-IN_16T_409920_Base.h
  group ReadMe
    ../../ReadMe/: Ver.cpp readme.txt
target LPC4078_WithBoot (ARM-ADS)
  device: LPC4078 NXP (founded by Philips)
  cpu: as above
  output: TYPro8_4078_2212301_IV +hex
  c flags: Optim=1 wLevel=2
  c define: BOOT_MODE
  c include: ..\Entry
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\OSProject_WithBoot.sct
