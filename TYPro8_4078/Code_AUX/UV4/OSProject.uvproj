# Keil uVision project OSProject.uvproj, settings and files
target LPC4078_WithoutBoot (ARM-ADS)
  device: LPC4078 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: OSProject +hex
  c flags: Optim=1 wLevel=2
  c include: ..\Entry
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\OSProject_WithoutBoot.sct
  group Entry
    ../Entry/: G_DF.h includes.h main.cpp
  group Task_Dispatcher
    ../../COMMON_OS/Task_Dispatcher/: OS_ServeProcess.cpp
  group Protocols
    ../../COMMON_OS/Protocols/: SF_Hwf.h CAN_Hwf.h
  group Data_Manipulation
    ../../COMMON_OS/Data_Manipulation/: Datatypes.cpp Datatypes.h Time_Consum.h CircularQueue_Lin.cpp CircularQueue.h Lib_Mem.cpp Time_Count.cpp Time_Count.h
  group MCU_Core
    ./: startup_LPC407x_8x_177x_8x.s
    ../../COMMON_OS/LPC4078CORE/: system_LPC407x_8x_177x_8x.c CAN.cpp EXTINT.cpp GPIO.cpp IRQ.cpp RTC.cpp SDRAM.cpp SSPI.cpp TIMERS.cpp WDT.cpp I2CNew.cpp UART.cpp ADC.cpp PWM.cpp PWM.h
  group Ext_Devices
    ../../COMMON_OS/Ext_Devices/: LEDFunc.cpp ADC24bit_ADS1259.cpp ADC32bit_LTC2449.cpp ADC32bit_LTC2498.cpp ADC16bit_LTC68042.cpp FM25L256.cpp EEPROM_24LC128.cpp ControlPin.cpp CPLD.cpp DAC16bit_AD5754.cpp DDS_AD9834.cpp ADC24bit_AD7175.cpp ADC101C027.cpp ADC101C027.h DAC6571.cpp DAC6571.h
  group TCP-NET
    ../../COMMON_OS/TCP-NET/: Net_Config.c Net_lib.c TcpTxRx.cpp TCP_CM3.lib EMAC_LPC177x_8x.cpp
  group EthernetParse
    ../../COMMON_APP/EthernetParse/: EthernetParse.cpp EthernetParse.h EventsBuffering.h EventsBuffering.cpp MultiMcuCommunication.cpp MultiMcuCommunication.h DebugReadMemory.cpp DebugReadMemory.h
  group Uart_Parse
    ../../COMMON_APP/UartParse/: Aux_UartParse.cpp DWIN_UartParse.cpp DWIN_UartParse.h
  group CAN_Bus
    ../../COMMON_APP/CANBus/: CANBusParse.cpp CANBusParse.h CANMsgBuffering.cpp CANMsgBuffering.h CanbusWatchdog.cpp
  group Aux_Tasks
    ../AUX_Tasks/: BSP.cpp BSP.h AUXDatamanager.cpp AUXDataManager.h AUXSampleProcess.cpp AUXSampleProcess.h AuxSDL.cpp AuxSDL.h AuxCheckLimit_4.cpp AUXCheckLimit_4.h AuxCheckLimit_8.cpp AuxCheckLimit_8.h AuxCConfig.cpp AuxCConfig.h Aux_SafeCheck.cpp Aux_SafeCheck.h Aux_ThirdParty.cpp Aux_ThirdParty.h AuxConfigRSN.cpp AuxConfigRSN.h Aux_RedundantSample.cpp AuxReadDI.cpp AuxWriteDO.cpp AUXSampleTask.cpp AUXSampleTask.h AuxRedundantSafetyCheck.cpp AuxSample_2ndV_LC.cpp AuxSample_2ndV_LC.h Aux_RedundantSafetyCheck.h AuxMetavariable.cpp AUX_PID.cpp AUX_PID.h AuxACIMTest.cpp AUX_SysCtrl.cpp AUX_SysCtrl.h POWERADJ.cpp POWERADJ.h
  group Aux_THChamber
    ../HWD/AUX_THChamber/: MTCI_CTRL.cpp TC_EUROTHERM_2204E.cpp TC_EUROTHERM_3216.cpp TC_FUTURE_FDCP91.cpp TC_KSI_THS2005.cpp TC_SAMWONTECH_TEMP880.cpp TC_TFS_PC200.cpp TC_THERMOTRON_8200.cpp TC_WATLOW_F4.cpp TH_CSZ_EZT570I.cpp TH_HARDING_TPC7062K.cpp TH_SAMWONTECH_TEMI2500.cpp TH_SIEMENS_S7_226CN.cpp TH_VOETSCH.cpp MTCI_Datatypes.cpp TC_SAMWONTECH_TEMP2500.cpp TH_CLCD_9700.cpp TH_SHANGHAI_PINDUN_TEMI880.cpp TH_SHANGHAI_PINDUN_TEMI880.h TH_CSZ_EZT430I.cpp TH_CSZ_EZT430I.h TC_BINDER_MB1.cpp TC_BINDER_MB1.h TH_DONGGUAN_HUANCE_UMC1200.cpp TH_GUANGZHOU_WUSUO.cpp TH_TT_5166.cpp TH_VOETSCH_VC_L4006.cpp TH_HARDINGS7_HLT504P.cpp TH_HARDINGS7_HLT504P.h TH_CHONGQING_YINHE_MODBUSTCP.h TH_CHONGQING_YINHE_MODBUSTCP.cpp TC_HARDINGS7_HLT403P-II.cpp TC_HARDINGS7_HLT403P-II.h TC_JULABO_FP50MA_F4.cpp TH_CHONGQING_ATAIHE.cpp TH_JUFU_9700S.cpp TH_ESPEC_SCP220.cpp TC_SUN_EC1X.cpp TH_ESPEC_GPL_4.cpp TH_ESPEC_GPL_4.h TH_SIEMENS_S7_SAIA.cpp TC_TM221CE24T.cpp TH_US_9256P_ACCU3.cpp TH_9700S_2C.cpp TH_SIEMENS_S7_XC1001A_SAIA.cpp TC_LAUDA_PRO_P2E.cpp TH_HITACHI_EC15MHP.cpp TC_JULABO_A45T.cpp TC_TEMI2500_MODBUS2.cpp TH_VOETSCH_NETWORK.cpp TC_HARDINGS7_HLT504P.cpp TC_MT8071_MODBUS.cpp TH_MemmertGmbH_RS232.cpp TC_ESPEC_GPL_4.cpp TC_ESPEC_SCP220.cpp TC_BINDER_MB2.cpp TC_BINDER_MB2.h TC_U740.cpp TC_U740.h TC_SIMPAC.cpp TC_SIMPAC.h TH_TT_5166_Sunwoda.cpp TH_SONGHUA_2PT_BD.cpp TC_9700S_2C.cpp TC_DONGDA_MEWTO.cpp TC_SIEMENS_S7_XC1001A_SAIA.cpp TH_MT8071_MODBUS.cpp TH_HONGRUIDA_MODBUS_TCP.cpp TC_BIA_CLIMATIC.cpp TH_ZUNDAR_AZ1000.cpp TC_SigmaSystemsC4.cpp TC_WATLOW_F4T_MODBUS_TCP.cpp TH_SPI2_P1.cpp TC_PolyScience.cpp TH_GT9700S.cpp TC_HARDING_THREE_LAYERS_MODBUS_TCP.cpp TC_HARDINGS7_V0_45A1-II.cpp TH_PLC_700_ASCII.cpp TH_HONGRUIDA_MODBUS_RS485.cpp TH_SIMENSE_S7_200.cpp TC_MT8071_MODBUS_DOUBLE_LAYER.cpp TC_H_OYO1000.cpp TC_WATLOW_F4T_MODBUS_FLOAT.cpp
  group Aux_2ndV_TR_509146
    ../HWD/Aux_2ndV_TR_509146/: Aux_2ndV_TR_509146_Base.cpp Aux_2ndV_TR_509146_Base.h
  group Aux_2ndV_HIM_511898_WMADC602540
    ../HWD/Aux_2ndV_HIM_511898_WMADC602540/: Aux_2ndV_HIM_511898_WMADC602540_Base.cpp Aux_2ndV_HIM_511898_WMADC602540_Base.h
  group Aux_P_TC_509138
    ../HWD/Aux_P_TC_509138/: Aux_P_TC_509138_Base.cpp Aux_P_TC_509138_Base.h
  group BatteryCells
    ../HWD/BatteryCells/: BatteryCells_ADC5DAC.cpp BatteryCells_Base.cpp BatteryCells_GPIO.cpp BatteryCells_SampleManage.cpp
  group Aux_MultiFunc_514194
    ../HWD/Aux_MultiFunc_514194/: Aux_MultiFunc_514194_Base.cpp Aux_MultiFunc_514194_Base.h
  group Aux_Redun_2ndV_TC_601082
    ../HWD/Aux_Redun_2ndV_TC_601082/: Aux_Redun_2ndV_TC_601082_Base.cpp Aux_Redun_2ndV_TC_601082_Base.h
  group Aux_ExtCharge_601618
    ../HWD/Aux_ExtCharge_601618/: Aux_ExtCharge_601618_Base.cpp Aux_ExtCharge_601618_Base.h
  group Aux_Monitor_601618
    ../HWD/Aux_Monitor_601618/: Aux_Monitor_601618_Base.cpp Aux_Monitor_601618_Base.h
  group Aux_2ndV_LC_601310
    ../HWD/Aux_2ndV_LC_601310/: Aux_2ndV_LC_601310_Base.cpp Aux_2ndV_LC_601310_Base.h
  group Aux_PT100_601314
    ../HWD/Aux_TR_PT100_601314/: Aux_TR_PT100_601314_Base.cpp Aux_TR_PT100_601314_Base.h
  group Aux_DIDO_601196_WMADC602518
    ../HWD/Aux_DIDO_601196_WMADC602518/: Aux_DIDO_601196_WMADC602518_Base.cpp Aux_DIDO_601196_WMADC602518_Base.h
  group Aux_OnlineRSM_602026
    ../HWD/Aux_OnlineRSM_602026/: Aux_OnlineRSM_602026_Base.cpp Aux_OnlineRSM_602026_Base.h
  group Aux_TC_MADC602280_WMADC602524
    ../HWD/Aux_TC_MAD602280_WMADC602524/: Aux_TC_MAD602280_WMADC602524_Base.cpp Aux_TC_MAD602280_WMADC602524_Base.h
  group Aux_AIO_DIO_602178_WMADC602548
    ../HWD/Aux_AIO_DIO_602178_WMADC602548/: Aux_AIO_DIO_602178_WMADC602548_Base.cpp Aux_AIO_DIO_602178_WMADC602548_Base.h
  group Aux_Chamber_TEC
    ../HWD/Aux_Chamber_TEC/: Aux_Chamber_TEC_Base.cpp Aux_Chamber_TEC_base.h HT16K33.cpp HT16K33.h TMP_KEYFun.cpp TMP_KEYFun.h TMP75_TEC.cpp TMP75_TEC.h
  group Aux_MTC
    ../HWD/Aux_MTC/: Aux_MTC_Base.cpp Aux_MTC_Base.h
  group Aux_TC_HS_MADC602176_WMADC602484
    ../HWD/Aux_TC_HS_MADC602176_WMADC602484/: Aux_TC_HS_MADC602176_WMADC602484_Base.cpp Aux_TC_HS_MADC602176_WMADC602484_Base.h
  group Aux_WMADC_PT100_602532
    ../HWD/Aux_WMADC_PT100_602532/: Aux_WMADC_PT100_602532_Base.cpp Aux_WMADC_PT100_602532_Base.h
  group Aux_WMADC_2ndV_TR_602536
    ../HWD/Aux_WMADC_2ndV_TR_602536/: Aux_WMADC_2ndV_TR_602536_Base.cpp Aux_WMADC_2ndV_TR_602536_Base.h
  group Aux_WMADC_2ndV_LC_602528_WMADC_603072_WM
    ../HWD/Aux_WMADC_2ndV_LC_602528_WMADC_603072_WMADC_603130/: Aux_WMADC_2ndV_LC_602528_WMADC_603072_WMADC_603130_Base.cpp Aux_WMADC_2ndV_LC_602528_WMADC_603072_WMADC_603130_Base.h
  group Aux_DDS_ACIM_ACR-408888
    ../HWD/Aux_DDS_ACIM_ACR_408888/: Aux_DDS_ACIM_ACR_408888_Base.cpp Aux_DDS_ACIM_ACR_408888_Base.h Aux_DDS_ACIM_ACR_408888_SampleManage.cpp Aux_DDS_ACIM_ACR_408888_SampleManage.h
  group Aux_SystemCtrlBoard_415016
    ../HWD/Aux_SystemCtrlBoard_415016/: Aux_SystemCtrlBoard_415016_Base.cpp Aux_SystemCtrlBoard_415016_Base.h
  group Aux_PowerADJ_200A_412206
    ../HWD/Aux_PowerADJ_200A_412206/: Aux_PowerADJ_200A_412206_Base.cpp Aux_PowerADJ_200A_412206_Base.h
  group Aux_PowerADJ_2US6K_422108
    ../HWD/Aux_PowerADJ_2US6K_422108/: Aux_PowerADJ_2US6K_422108_Base.cpp Aux_PowerADJ_2US6K_422108_Base.h
  group ReadMe
    ../../ReadMe/: Ver.cpp readme.txt
target LPC4078_WithBoot (ARM-ADS)
  device: LPC4078 NXP (founded by Philips)
  cpu: as above
  output: TYPro8_4078_2212301_Aux +hex
  c flags: Optim=1 wLevel=2
  c define: BOOT_MODE
  c include: ..\Entry
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\OSProject_WithBoot.sct
